#include<p18f8722.inc>
	clrf TRISD, 0
	MOVLW 0x00
	MOVWF PORTD, 0
DOWN MOVLW 0x55
	MOVWF PORTD
	CALL DELAY
	GOTO UP
UP MOVLW 0xAA
	MOVWF PORTD
	CALL DELAY
	GOTO DOWN

DELAY
	DCounter1 EQU 0X0C
	DCounter2 EQU 0X0D
	DCounter3 EQU 0X0E
	MOVLW 0X6d
	MOVWF DCounter1
	MOVLW 0X5e
	MOVWF DCounter2
	MOVLW 0X1a
	MOVWF DCounter3
	LOOP DECFSZ DCounter1, 1
	GOTO LOOP
	DECFSZ DCounter2, 1
	GOTO LOOP
	DECFSZ DCounter3, 1
	GOTO LOOP
	RETURN
END